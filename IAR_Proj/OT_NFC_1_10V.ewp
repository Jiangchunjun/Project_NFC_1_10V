# IAR project OT_NFC_1_10V.ewp, settings and files
configuration 200W (ARM, debug)
  General.OGChipSelectEditMenu: XMC1302-T038x0064 Infineon XMC1302-T038x0064
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: XMC1301_T038x0064; OT_NFC_IP67_200W; NDEBUG; ENABLT_WDT; ENABLE_COMM; ENABLE_USART; nDEBUG_PRINT; nDEBUG_VERSION; MODULE_I2C; MODULE_M24LRxx; MODULE_NFC; MODULE_NFC_DALI; ENASTRO; NO_FAST_TIME_ASTRO; NO_EN_CLM_TIME_FAST; ENABLE_OVP; ENABLE_MOBILE; ENABLE_ONE2TEN; BYTEORDER_LITTLE_ENDIAN; AVAILABLE_PORTS_NUMBER=3; FW_HIGH=01; FW_LOW=02; ENASTRO; MPC_O2T_DEFAULT_SETTINGS; MPC_O2T_DEFAULT_BOUNDARIES
  ICCARM.CCIncludePath2: ..\XMC_Peripheral_Library\XMCLib\inc; ..\XMC_Peripheral_Library\CMSIS\Infineon\XMC1300_series\Include; ..\XMC_Peripheral_Library\CMSIS\Include; ..\Application\inc; ..\Driver\inc; ..\Import\Config\devices; ..\Import\Config; ..\Import\driver_ot; ..\Import\modules\CRC\api; ..\Import\modules\CRC\driver_api; ..\Import\modules\fileTank; ..\Import\modules\I2cExt\api; ..\Import\modules\I2cExt\driver_api; ..\Import\modules\NfcExt\api; ..\Import\modules\NfcExt\M24LRxx; ..\Application\src\modules\NVM; PROJ_DIR$\..\Application\src\modules\NVM\api; ..\Application\src\modules\NVM\driver_api\; ..\Application\src\modules\NVM\driver_xmc1300\; ..\Application\src\modules\CRC\api; ..\Application\src\modules\CRC\driver_api\; ..\Application\src\modules\currentset; ..\Application\src\modules\supplymonitor; ..\Application\src\modules\Dali\DaliServices; ..\Application\src\modules\Dali\HW; ..\Application\src\modules\Dali\iFace\Modules; ..\Application\src\modules\Dali\iFace\Optional; ..\Application\src\modules\Dali\iFace\Services; ..\Application\src\modules\MPC\Acl; ..\Application\src\modules\MPC\Alloc; ..\Application\src\modules\MPC\Alloc\Legacy; ..\Application\src\modules\MPC\Clm; ..\Application\src\modules\MPC\Csm; ..\Application\src\modules\MPC\Info; ..\Application\src\modules\MPC\MSK; ..\Application\src\modules\MPC\O2T; ..\Application\src\modules\MPC\AstroDim; ..\Application\src\modules\MPC\MSKEncryption; ..\Application\src\modules\MPC\Power; ..\Application\src\modules\MPC\EOL; ..\Application\src\modules\NFC; ..\Application\src\modules\I2C; ..\Application\src\modules\XMCLib\XMCLib\inc; ..\Application\src\modules\XMCLib\CMSIS\Include; ..\Application\src\modules\XMCLib\CMSIS\Infineon\XMC1300_series\Include; ..\Application\src\modules\CRC16; ..\Application\src\hwdrivers\XMC1300; ..\Application\src\modules\NVM\api; ..\Application\src\modules\supplymonitor
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OT_1_10V_200W_V2.hex
  ILINK.IlinkOutputFile: OT_NFC_IP67.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Infineon\XMC1302xxxxx64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 150W (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1302-T038x0200 Infineon XMC1302-T038x0200
  ICCARM.CCDefines: XMC1301_T038x0064; OT_NFC_IP67_150W; NDEBUG; ENABLT_WDT; ENABLE_COMM; ENABLE_USART; DEBUG_PRINT; nDEBUG_VERSION; MODULE_I2C; MODULE_M24LRxx; MODULE_NFC; MODULE_NFC_DALI; ENASTRO; NO_FAST_TIME_ASTRO; NO_EN_CLM_TIME_FAST; ENABLE_OVP; ENABLE_MOBILE; ENABLE_ONE2TEN; ENABLE_LOOP_OVP_OCP1; BYTEORDER_LITTLE_ENDIAN; AVAILABLE_PORTS_NUMBER=3; FW_HIGH=03; FW_LOW=02; ENASTRO; MPC_O2T_DEFAULT_SETTINGS; MPC_O2T_DEFAULT_BOUNDARIES
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: OT_1_10V_150W_V2.hex
  ILINK.IlinkIcfFile: normal_config.icf
configuration 100W (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1302-T038x0200 Infineon XMC1302-T038x0200
  ICCARM.CCDefines: XMC1301_T038x0064; OT_NFC_IP67_100W; NDEBUG; ENABLT_WDT; ENABLE_COMM; ENABLE_USART; nDEBUG_PRINT; nDEBUG_VERSION; MODULE_I2C; MODULE_M24LRxx; MODULE_NFC; MODULE_NFC_DALI; ENASTRO; NO_FAST_TIME_ASTRO; NO_EN_CLM_TIME_FAST; ENABLE_OVP; ENABLE_MOBILE; ENABLE_ONE2TEN; BYTEORDER_LITTLE_ENDIAN; AVAILABLE_PORTS_NUMBER=3; FW_HIGH=03; FW_LOW=02; ENASTRO; MPC_O2T_DEFAULT_SETTINGS; MPC_O2T_DEFAULT_BOUNDARIES
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: OT_1_10V_100W_V2.hex
  ILINK.IlinkIcfFile: normal_config.icf
configuration 60W (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1302-T038x0200 Infineon XMC1302-T038x0200
  ICCARM.CCDefines: XMC1301_T038x0064; OT_NFC_IP67_60W; NDEBUG; ENABLT_WDT; ENABLE_COMM; ENABLE_USART; nDEBUG_PRINT; nDEBUG_VERSION; MODULE_I2C; MODULE_M24LRxx; MODULE_NFC; MODULE_NFC_DALI; ENASTRO; NO_FAST_TIME_ASTRO; NO_EN_CLM_TIME_FAST; ENABLE_OVP; ENABLE_MOBILE; ENABLE_ONE2TEN
  ICCARM.CCIncludePath2: ..\XMC_Peripheral_Library\XMCLib\inc; ..\XMC_Peripheral_Library\CMSIS\Infineon\XMC1300_series\Include; ..\XMC_Peripheral_Library\CMSIS\Include; ..\Application\inc; ..\Driver\inc; ..\Import\Config\devices; ..\Import\Config; ..\Import\driver_ot; ..\Import\modules\CRC\api; ..\Import\modules\CRC\driver_api; ..\Import\modules\fileTank; ..\Import\modules\I2cExt\api; ..\Import\modules\I2cExt\driver_api; ..\Import\modules\NfcExt\api; ..\Import\modules\NfcExt\M24LRxx
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: OT_1_10V_60W_V1.hex
  ILINK.IlinkIcfFile: normal_config.icf
  group (top)
    ../: Readme.txt
  group Application/Header
    ../Application/inc/: aes.h comm_task.h ConfigDali.h ConfigMpc.h ConfigNfc.h ConfigNvm.h filter.h mcu_config.h power_config_100w.h power_config_150w.h power_config_200w.h power_config_60w.h power_task.h system.h tag.h
  group Application/Source
    ../Application/src/: aes.c comm_task.c driver.c filter.c main.c mcu_config.c power_task.c system.c tag.c
  group CRC16
    ../Application/src/modules/CRC16/: crc16.c crc16.h
  group Dalli
    ../Application/src/modules/Dali/DaliBin/: Config_OUTD_1LP.h Config_T6_1LP_TDC.h DaliLib13709_T6_1LP_TDC.a OutdoorLib_1LP.a
    ../Application/src/modules/Dali/DaliServices/: DaliServices.c ProductionTest.c
    ../Application/src/modules/Dali/HW/: DaliUart_XMC.c
  group Driver/Header
    ../Driver/inc/: acmp.h adc.h eru.h gpio_xmc1300_tssop38.h pwm.h simu_i2c.h sw_timer.h tick.h ttypes.h usart.h wdt.h
  group Driver/Source
    ../Driver/src/: acmp.c adc.c eru.c pwm.c simu_i2c.c sw_timer.c tick.c usart.c wdt.c
  group hwdrivers
    ../Application/src/hwdrivers/XMC1300/: xmc1300_ports_hwdriver.c xmc1300_ports_hwdriver.h
  group I2C
    ../Application/src/modules/I2C/: i2c_config.c i2c_config.h i2c_driver.h i2c_driver_xmc1300.c i2c_local.h i2c_module.c i2c_parameters_XMC1300.h i2c_userinterface.h
  group Library/CMSIS
    ../XMC_Peripheral_Library/CMSIS/Infineon/XMC1300_series/Source/IAR/: startup_XMC1300.s
    ../XMC_Peripheral_Library/CMSIS/Infineon/XMC1300_series/Source/: system_XMC1300.c
  group Library/XMClib
    ../XMC_Peripheral_Library/XMCLib/src/: xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc_acmp.c xmc_bccu.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_eru.c xmc_gpio.c xmc_i2c.c xmc_ledts.c xmc_math.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c
  group module_crc
    ../Application/src/modules/CRC/api/: crc.c
    ../Application/src/modules/CRC/driver_sw/: crc_driver_sw.c
  group module_nvm
    ../Application/src/modules/NVM/driver_xmc1300/: flash_driver_xmc1300.c
    ../Application/src/modules/NVM/api/: nvm.c
  group module_supplymonitor
    ../Application/src/modules/supplymonitor/: SupplyMonitor.c SupplyMonitor.h supplymonitor_local.h supplymonitor_parameters.h SupplyMonitor_userinterface.h SupplyMonitorDefaults.h SupplyMonitorStructsInit.c SupplyMonitorStructsInit.h
  group MPC/Acl
    ../Application/src/modules/MPC/Acl/: Acl.c Acl.h AclDefaults.h
  group MPC/Alloc
    ../Application/src/modules/MPC/Alloc/: Mpc.c Mpc.h MpcAllocation.c MpcAllocation.h MpcDefaultConfiguration.h MpcDescriptors.c MpcDescriptors.h MpcIncludeAll.h MpcInternal.h MpcPerm4Legacy.c MpcPerm4Legacy.h
  group MPC/Alloc_Legacy
    ../Application/src/modules/MPC/Alloc/Legacy/: MemoryBanksGeneric.c MemoryBanksGeneric.h MpcDefs.h MpcLegacy.h MpcServices.h
  group MPC/AstroDim
    ../Application/src/modules/MPC/AstroDim/: MemoryBank_Astro.c MemoryBank_Astro.h
  group MPC/CLM
    ../Application/src/modules/MPC/Clm/: MemoryBank_Clm.c MemoryBank_Clm.h
  group MPC/CSM
    ../Application/src/modules/MPC/Csm/: MemoryBank_Csm.c MemoryBank_Csm.h
  group MPC/EOL
    ../Application/src/modules/MPC/EOL/: MemoryBank_Eol.c MemoryBank_Eol.h
  group MPC/Info
    ../Application/src/modules/MPC/Info/: MemoryBank_Info.c MemoryBank_Info.h MpcInfo_Services.h
  group MPC/MSK
    ../Application/src/modules/MPC/MSK/: MSK.c MSK.h MSK_internal.h MSK_local.h
  group MPC/MSK_Encryption
    ../Application/src/modules/MPC/MSKEncryption/: MskEncryption-CortexM0-LittleEndian-IAR7.60.a
  group MPC/O2T
    ../Application/src/modules/MPC/O2T/: O2T.c O2T.h O2T_private.h
  group NFC
    ../Application/src/modules/NFC/: Nfc.h nfc_config.c nfc_config.h nfc_local.h nfc_module.c nfc_parameters.h
