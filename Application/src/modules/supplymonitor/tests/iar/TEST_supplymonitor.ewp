# IAR project TEST_supplymonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC1302-T038x0200 Infineon XMC1302-T038x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; UNIT_TESTING
  ICCARM.CCIncludePath2: ..\..\..\..\XMC1300\CMSIS\; ..\..\..\..\; ..\..\..\..\kernel; ..\..\..\..\hwdrivers\XMC1300; ..\..\..\..\modules\boostpfc; ..\..\..\..\modules\dataout; ..\..\..\..\modules\buck; ..\..\..\..\test; ..\..\..\..\test\test_framework; ..\..\..\..\test\test_framework\unity; ..\..\..\..\Config; ..\..\..\..\modules\Dali\DaliInterfaces\Interface_DaliServices; ..\..\..\..\modules\Dali\DaliInterfaces\Interface_DaliBallast; ..\..\..\..\modules\Dali\DaliInterfaces\Interface_MemoryBanks; ..\..\..\..\modules\Dali\DaliInterfaces; ..\..\..\..\modules\Dali\DaliServices; ..\..\..\..\modules\Dali\DaliHwDriver; ..\..\..\..\modules\Dali\DaliLib; ..\..\..\..\modules\os; ..\..\..\..\modules\polpocom; ..\..\..\..\modules\NVM\api; ..\..\..\..\modules\NVM\driver_api\; ..\..\..\..\modules\NVM\driver_xmc1300\; ..\..\..\..\modules\CRC\api; ..\..\..\..\modules\CRC\driver_api\; ..\..\..\..\modules\CRC\driver_xmc1300\; ..\..\..\..\modules\god; ..\..\..\..\modules\VirginRampUp; ..\..\..\..\modules\currentset; ..\..\..\..\modules\linemonitor; ..\..\..\..\modules\supplymonitor; ..\..\..\..\Config; ..\..\..\..\modules\pimp; ..\..\..\..\modules\nvm; ..\..\..\..\modules\DataExchange
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: OTi_NONSELV_G2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1302-T038x0064 Infineon XMC1302-T038x0064
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: PA050
  ICCARM.CCIncludePath2: ..\src\XMC1300\CMSIS\; ..\src; ..\src\kernel; ..\src\hwdrivers\XMC1300; ..\src\modules\boostpfc; ..\src\modules\dataout; ..\src\modules\buck; ..\src\test; ..\src\test\test_framework; ..\src\Config; ..\src\modules\Dali\DaliInterfaces\Interface_DaliServices; ..\src\modules\Dali\DaliInterfaces\Interface_DaliBallast; ..\src\modules\Dali\DaliInterfaces\Interface_MemoryBanks; ..\src\modules\Dali\DaliInterfaces; ..\src\modules\Dali\DaliServices; ..\src\modules\Dali\DaliHwDriver; ..\src\modules\Dali\DaliLib; ..\src\modules\os; ..\src\modules\polpocom; ..\src\modules\NVM\api; ..\src\modules\NVM\driver_api\; ..\src\modules\NVM\driver_xmc1300\; ..\src\modules\CRC\api; ..\src\modules\CRC\driver_api\; ..\src\modules\CRC\driver_xmc1300\; ..\src\modules\god; ..\src\modules\VirginRampUp; ..\src\modules\currentset; ..\src\modules\linemonitor; ..\src\modules\supplymonitor; ..\src\Config; ..\src\modules\pimp; ..\src\modules\nvm; ..\src\modules\DataExchange
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: OTi_NONSELV_G2.hex
  prebuild: python SvnStat.py $PROJ_DIR$  ..\src\Config\build_version.h
  group external
    ../../../../kernel/: filter.c filter.h
  group module
    ../../: SupplyMonitor.c SupplyMonitor.h supplymonitor_local.h supplymonitor_parameters.h SupplyMonitor_userinterface.h SupplyMonitorDefaults.h SupplyMonitorStructsInit.c SupplyMonitorStructsInit.h
  group test
    ../: test_runner_supplymonitor.c test_supplymonitor_adjust_Ulinepk.c test_supplymonitor_basic.c test_supplymonitor_evaluate.c test_supplymonitor_integration.c test_supplymonitor_level_fsm.c test_supplymonitor_overwrites.h
  group test_framework
    ../../../../test/test_framework/: unit_testing_utilities.c
    ../../../../test/test_framework/unity/: unity.c unity_fixture.c
